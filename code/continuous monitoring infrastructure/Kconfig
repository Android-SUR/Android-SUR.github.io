## code/continuous monitoring infrastructure/Kconfig
```kconfig
config LOG
	tristate "log"
	default n

config EXCEPTION_LOG
	tristate "exception log"
	default n
```
